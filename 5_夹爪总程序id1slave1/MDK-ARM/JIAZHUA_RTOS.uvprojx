# Keil uVision project JIAZHUA_RTOS.uvprojx, settings and files
target JIAZHUA_RTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: JIAZHUA_RTOS +hex
  AfterMake: fromelf.exe --bin --output .\JIAZHUA_RTOS\gripper1_app.bin .\JIAZHUA_RTOS\JIAZHUA_RTOS.axf
  AfterMake: fromelf.exe --bin --output ..\..\OTA_PC_Tool\gripper1_app.bin .\JIAZHUA_RTOS\JIAZHUA_RTOS.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,APP_VECT_TAB_OFFSET=0x00006000U
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../User/AS5048A;../User/Motor;../User/Pressure_Sensor;../User/UART1_Print;../User/Modbus;../User/OTA;..\User\Force_Estimator
  asm include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x7fe0
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User/AS5048A
    ../User/AS5048A/: AS5048A.c AS5048A.h
  group User/Motor
    ../User/Motor/: bsp_fdcan.c bsp_fdcan.h dm_motor_ctrl.c dm_motor_ctrl.h dm_motor_drv.c dm_motor_drv.h
  group User/Pressure_Sensor
    ../User/Pressure_Sensor/: Pressure_Sensor.h Pressure_Sensor.c pressure_history.c
  group User/UART1_Print
    ../User/UART1_Print/: UART1_Print.c UART1_Print.h
  group User/Modbus
    ../User/Modbus/: dm_modbus_bridge.c dm_modbus_bridge.h pos_persist.c pos_persist.h rs485.h
  group User/Force_Estimator
    ../User/Force_Estimator/: force_estimator.c force_estimator.h
  group User/OTA
    ../User/OTA/: gripper_ota_app.c gripper_ota_app.h gripper_ota_layout.h
software components: CMSIS:CORE 4.3.0
